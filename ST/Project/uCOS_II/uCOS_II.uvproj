# Keil uVision project uCOS_II.uvproj, settings and files
target uCOS_II (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS_II
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\SDK\Core\inc;..\..\SDK\Libraries\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3 Core
    ../../SDK/Core/startup/: startup_stm32f10x_md.s
    ../../SDK/Core/src/: system_stm32f10x.c core_cm3.c
  group Apllication Code
    ./src/: main.c
