# Keil uVision project SD_FS.uvproj, settings and files
target SD_FS (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_FS +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\SDK\3.1.2\Libraries\CMSIS\Core\CM3;..\..\SDK\3.1.2\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Inc;.\Efsl\base\Inc;.\Efsl\driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ../../SDK/3.1.2/Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../SDK/3.1.2/Libraries/CMSIS/Core/CM3/: system_stm32f10x.c core_cm3.c
  group Library
    ../../SDK/3.1.2/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_spi.c
  group EFSL_Base
    ./Efsl/base/Src/: debug.c dir.c disc.c efs.c extract.c fat.c file.c fs.c ioman.c ls.c mkfs.c partition.c plibc.c time.c ui.c
  group EFSL_Driver
    ./Efsl/driver/Src/: sd.c
  group Apllication Code
    ./Src/: main.c hw_config.c stm32f10x_it.c Retarget.c task.c cmd_parse.c cmd_array.c msd.c
