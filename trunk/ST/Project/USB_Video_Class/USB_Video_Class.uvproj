# Keil uVision project USB_Video_Class.uvproj, settings and files
target USB_Video_Class (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: USB_Video_Class
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: .\inc;..\..\SDK\USB_FS\inc;..\..\SDK\Libraries\inc;..\..\SDK\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3 Core
    ../../SDK/Core/src/: core_cm3.c system_stm32f10x.c
    ../../SDK/Core/startup/: startup_stm32f10x_md.s
  group Libraries USB
    ../../SDK/USB_FS/src/: usb_regs.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group Libraries Periph
    ../../SDK/Libraries/src/: misc.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c
  group Application Code
    ./src/: main.c stm32f10x_it.c
