# Keil uVision project VirtualCOMPort.uvproj, settings and files
target Virtual_COM_Port (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: .\inc;..\..\SDK\Libraries\inc;..\..\SDK\USB_FS\inc;..\..\SDK\Core\inc;..\..\SDK\STM32_EVAL;..\..\SDK\STM32_EVAL\STM3210B_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./src/: usb_pwr.c hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c
  group USB-FS-Device_Driver
    ../../SDK/USB_FS/src/: usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c usb_core.c otgd_fs_pcd.c otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c
  group StdPeriph_Driver
    ../../SDK/Libraries/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_exti.c
  group CMSIS
    ../../SDK/Core/startup/: startup_stm32f10x_md.s
    ../../SDK/Core/src/: system_stm32f10x.c core_cm3.c
  group STM32_EVAL
    ../../SDK/STM32_EVAL/: stm32_eval.c
  group Doc
    ./: readme.txt
