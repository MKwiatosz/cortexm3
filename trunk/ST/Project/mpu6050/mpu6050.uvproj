# Keil uVision project mpu6050.uvproj, settings and files
target mpu6050 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mpu6050 +hex
  c flags: oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\SDK\Core\inc;..\..\SDK\Libraries\inc;.\Inc;.\Efsl\base\Inc;.\Efsl\driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3 Core
    ../../SDK/Core/startup/: startup_stm32f10x_md.s
    ../../SDK/Core/src/: system_stm32f10x.c core_cm3.c
  group Library
    ../../SDK/Libraries/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_usart.c stm32f10x_spi.c
  group Apllication Code
    ./Src/: task.c Retarget.c cmd_array.c cmd_parse.c hw_config.c main.c stm32f10x_it.c
    ./src/: lcd.c uart_app.c gpio_app.c nvic_app.c MPU6050.c
