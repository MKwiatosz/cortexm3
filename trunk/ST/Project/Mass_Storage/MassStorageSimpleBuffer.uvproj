# Keil uVision project MassStorageSimpleBuffer.uvproj, settings and files
target Mass_Storage (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Mass_Storage
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: .\inc;..\..\SDK\USB_FS\inc;..\..\SDK\Libraries\inc;..\..\SDK\Core\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./src/: usb_scsi.c fsmc_nand.c hw_config.c main.c mass_mal.c memory.c msd.c nand_if.c scsi_data.c sdcard.c stm32f10x_it.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB-FS-Device_Driver
    ../../SDK/USB_FS/src/: usb_regs.c usb_core.c usb_init.c usb_int.c usb_mem.c
  group StdPeriph_Driver
    ../../SDK/Libraries/src/: stm32f10x_spi.c misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c
  group RVMDK
    ./src/: startup_stm32f10x_hd.s
  group CMSIS
    ../../SDK/Core/src/: core_cm3.c system_stm32f10x.c
