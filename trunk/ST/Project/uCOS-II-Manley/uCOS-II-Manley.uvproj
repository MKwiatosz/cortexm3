# Keil uVision project uCOS-II-Manley.uvproj, settings and files
target uCOS-II-Manley (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL-OS-Probe
  c flags: Optim=2 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\APP\inc;.\BSP\inc;..\..\SDK\Core\inc;..\..\SDK\Libraries\inc;..\..\SDK\uC_CPU\inc;..\..\..\uCOS_II_V2.86\uCOS-II\inc;..\..\SDK\uC_Port\ini;..\..\SDK\uC_LIB\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\STM32_Flash.scat
  link misc: --entry ResetHndlr
  group APP
    ./APP/src/: app.c vectors.s
  group BSP
    ./BSP/src/: bsp.c init.s bsp_periph.c bsp_int.c LCD.c Retarget.c
  group CM3 Core
    ../../SDK/Core/src/: system_stm32f10x.c core_cm3.c
  group Libraries
    ../../SDK/Libraries/src/: stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_tim.c misc.c
  group uC-CPU
    ../../SDK/uC_CPU/src/: cpu_a.asm cpu_c.c
  group uC-OS-II/Source
    ../../../uCOS_II_V2.86/uCOS-II/src/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group uC-OS-II/Port
    ../../SDK/uC_Port/src/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uC-LIB
    ../../SDK/uC_LIB/src/: lib_mem_a.asm lib_str.c lib_mem.c
