# Keil uVision project uCOS_II.uvproj, settings and files
target uCOS_II (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS_II
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\..\SDK\Core\inc;..\..\SDK\Libraries\inc;..\..\..\uCOS_II_V2.86\uCOS-II\inc;..\..\SDK\uC_Port\ini;..\..\SDK\uC_CPU\inc;..\..\SDK\uC_LIB\inc;.\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3 Core
    ../../SDK/Core/startup/: startup_stm32f10x_md.s
    ../../SDK/Core/src/: system_stm32f10x.c core_cm3.c
  group Library
    ../../SDK/Libraries/src/: misc.c stm32f10x_rcc.c
  group uCOS_II
    ../../../uCOS_II_V2.86/uCOS-II/src/: os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c
  group uC_Port
    ../../SDK/uC_Port/src/: os_dbg.c os_cpu_c.c os_cpu_a.asm
  group uC_CPU
    ../../SDK/uC_CPU/src/: cpu_c.c cpu_a.asm
  group uC_Lib
    ../../SDK/uC_LIB/src/: lib_str.c lib_mem.c lib_mem_a.asm
  group Apllication Code
    ./src/: main.c app.c bsp.c
