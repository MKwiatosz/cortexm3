# Keil uVision project manley_lcd.uvproj, settings and files
target manley_lcd (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: manley_lcd +hex
  c flags: Optim=1
  c include: ..\library\inc;.\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ../Startup/: cortexm3_macro.s stm32f10x_vector.s
  group Library Code
    ../library/src/: stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
    D:/Keil/ARM/Startup/: Retarget.c
  group Application Code
    ./: lcd.c stm32f10x_it.c main.c
